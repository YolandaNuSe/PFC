# Keil uVision project ADC.uvproj, settings and files
target ADCchannels (ARM-ADS)
  device: ADuCRF101 Analog Devices
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x0000000-0x001FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: ADC +hex
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ../../Common/RealView/: startup_ADuCRF101.s
    ./: main.c switches.c batery.c leds.c microphone.c radioeng.c config.c
target ADCcont (ARM-ADS)
  device: ADuCRF101 Analog Devices
  cpu: as above
  output: ADC
  c flags: Optim=1
  c include: ..\..\Common;..\..\DasLib;C:\keilv413a\arm\RV31\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target ADCcontDMA (ARM-ADS)
  device: ADuCRF101 Analog Devices
  cpu: as above
  output: ADC
  c flags: Optim=1
  c include: ..\..\Common;..\..\DasLib;C:\Keilv413a\ARM\RV31\INC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target ADCtimerDMA (ARM-ADS)
  device: ADuCRF101 Analog Devices
  cpu: as above
  output: ADC
  c flags: Optim=1
  c include: ..\..\Common;..\..\DasLib;C:\Keilv413a\ARM\RV31\INC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target ADCtimerOverflow (ARM-ADS)
  device: ADuCRF101 Analog Devices
  cpu: as above
  output: ADC
  c flags: Optim=1
  c include: ..\..\Common;..\..\DasLib;C:\Keilv413a\ARM\RV31\INC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target RatioMetric (ARM-ADS)
  device: ADuCRF101 Analog Devices
  cpu: as above
  output: ADC
  c flags: Optim=1
  c include: ..\..\Common;..\..\DasLib;C:\Keilv413a\ARM\RV31\INC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target TempSensor (ARM-ADS)
  device: ADuCRF101 Analog Devices
  cpu: as above
  output: ADC
  c flags: Optim=1
  c include: ..\..\Common;..\..\DasLib;C:\Keilv413a\ARM\RV31\INC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
