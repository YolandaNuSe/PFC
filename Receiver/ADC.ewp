# IAR project ADC.ewp, settings and files
configuration ADCchannels (ARM, debug)
  General.OGChipSelectEditMenu: ADUCRF101 AnalogDevices ADUCRF101
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pe188
  ICCARM.CCIncludePath2: ..\..\Common; ..\..\DasLib; $EW_DIR$\arm\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADuCM301.hex
  ILINK.IlinkOutputFile: Output.out
  ILINK.IlinkIcfFile: ..\..\Common\IAR\ADUCRF101.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ADCcont (ARM, debug)
  as the first configuration, except:
configuration ADCcontDMA (ARM, debug)
  as the first configuration, except:
configuration ADCtimerDMA (ARM, debug)
  as the first configuration, except:
configuration ADCtimerOverflow (ARM, debug)
  as the first configuration, except:
configuration RatioMetric (ARM, debug)
  as the first configuration, except:
configuration TempSensor (ARM, debug)
  as the first configuration, except:
  group Application
    src/: ADCchannels.c ADCcont.c ADCcontDMA.c ADCRatioMetric.c ADCTempSensor.c ADCtimerDMA.c ADCtimerOverflow.c
  group Common
    ../../Common/IAR/: Retarget.c startup_ADuCRF101.s
    ../../Common/: uart.c
  group Libraries
    ../../DasLib/: AdcLib.c ClkLib.c DioLib.c GptLib.c IntLib.c PwrLib.c RstLib.c SpiLib.c UrtLib.c WdtLib.c WutLib.c
